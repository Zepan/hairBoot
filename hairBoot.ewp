# IAR project hairBoot.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: hairBoot.hex
  ILINK.IlinkOutputFile: hairBoot.out
  ILINK.IlinkIcfFile: C:\work\singlecue\hairBoot-eyesight\lnkstm8s103f3.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: bootloader.c bootloader.h lnkstm8s103f3.icf make.bat out2hex.bat stm8s.h
